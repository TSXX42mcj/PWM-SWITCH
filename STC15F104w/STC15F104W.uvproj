# Keil uVision project STC15F104W.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F104W STC
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: STC15F104W +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\STC15F104w
  group Source Group 1
    ./: STARTUP.A51 main.c
